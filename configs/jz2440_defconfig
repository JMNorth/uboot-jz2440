## configs/jz2440_defconfig
```kconfig
CONFIG_ARM=y
CONFIG_TARGET_JZ2440=y
CONFIG_SYS_PROMPT="JZ2440 # "
CONFIG_SYS_TEXT_BASE=0x33F80000
```
